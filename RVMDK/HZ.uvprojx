# Keil uVision project HZ.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: HZ +hex
  c flags: Optim=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\APP;..\BSP;..\RVMDK;..\STM32F10x_FWLib\inc;..\APP\FATFS\doc\en;..\APP\FATFS\doc\img;..\APP\FATFS\doc\ja;..\APP\FATFS\exfuns;..\CORE;..\APP\FATFS\src
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group RVMDK
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group BSP
    ../BSP/: delay.c flash.c lcd.c malloc.c MMC_SD.C spi.c sys.c usart.c pstwo.c Timer3.c
  group APP
    ../APP/: fontupd.c text.c Tasks.c protocol.c
    ../APP/FATFS/src/: diskio.c ff.c
    ../APP/FATFS/exfuns/: exfuns.c fattester.c mycc936.c
  group FWLIB
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
